<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>mult</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value>11100001111101010</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>11</value></param>
<param><key>preamble</key><value>1100110011</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>mult</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>rf_samp_rate</value></param>
<param><key>center_freq0</key><value>2.4e9+5e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"vid=0x2500,pid=0x0020"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
