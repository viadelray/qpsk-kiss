<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_demo</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>970000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e3</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>2000e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>(6.28)/100.0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>0.047</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>0.06</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter</value></param>
<param><key>center_freq</key><value>offset</value></param>
<param><key>decim</key><value>int(rf_samp_rate/baseband_samp_rate)</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,rf_samp_rate,baseband_samp_rate*2,baseband_samp_rate*2*0.1)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>rf_samp_rate</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.4e9+4e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value>Out</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>rf_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter</source_block_id><sink_block_id>digital_pfb_clock_sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>freq_xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
